# IAR project gd32f303.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F303; USE_STDPERIPH_DRIVER; GD32F30X_HD; false=0; true=1
  ICCARM.CCIncludePath2: library\GD32F30x_Firmware_Library_V2.1.0\Firmware\GD32F30x_standard_peripheral\Include; library\GD32F30x_Firmware_Library_V2.1.0\Firmware\CMSIS\GD\GD32F30x\Include; library\GD32F30x_Firmware_Library_V2.1.0\Firmware\CMSIS; service; bsp; bsp\inc; os\rt-thread\include; os\rt-thread\components\finsh; tasks; tasks\maintask; os\rt-thread\libcpu\arm\cortex-m4; $PROJ_DIR$; os\rt-thread; dlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: output/gd32f303.bin
  ILINK.IlinkOutputFile: gd32f303.out
  ILINK.IlinkIcfFile: D:\Users\admin\Desktop\new_file\gd32f303_project\gd32f303_project\gd32f303.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    bsp/: board.c device_info.c drv_serial.c drv_spi.c
  group cmsis
    library/GD32F30x_Firmware_Library_V2.1.0/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group dlib
    dlib/: dlib.c
  group library
    library/GD32F30x_Firmware_Library_V2.1.0/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group mainapp
    mainapp/: color_light.c fan_speed_measure.c fan_speed_measure.h fan_test.c heater.c light_bar.c main.c protocol.c iap.c protocol.h protocol_app.c temp_measure.c temp_measure.h usart_Communication.c usart_Communication.h windows.c windows.h
  group os/core
    bsp/: dev_serial.c
  group os/kernel
    os/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group os/libcpu
    os/rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group os/shell
    os/rt-thread/components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group service
    service/: init.c job.c json.c myport.c singlefsm.c sync_event.c task_base.c
  group startup
    library/GD32F30x_Firmware_Library_V2.1.0/Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
  group tasks
    tasks/maintask/: main_task.c test_job.c
